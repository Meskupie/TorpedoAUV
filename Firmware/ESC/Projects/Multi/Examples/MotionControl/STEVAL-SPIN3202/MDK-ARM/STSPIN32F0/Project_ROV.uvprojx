# Keil uVision project Project_ROV.uvprojx, settings and files
target STSPIN32F0A (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F031C6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Project_Uart
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=$l@L.bin !L
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NO_ROV,USE_HAL_DRIVER,STM32F031x6,UART_COMM,NO_PID,HALL_SENSORS,NO_ALL_WINDINGS_ENERGIZATION,FIXED_HALL_DELAY,NO_PWM_ON_BEMF_SENSING,NO_MC_FAN_4PP_24V,NO_MC_RS_57BL54,NO_MC_2036_U_024_B_K312,NO_MC_BR2804_1700_KV_1,MC_SUPPO_2217_9_950_KV,DELTA_6STEP_TABLE,COMPLEMENTARY_DRIVE,NO_VOLTAGE_MODE,NO_POTENTIOMETER,NO_CURRENT_SENSE_ADC,NO_VBUS_SENSE_ADC,NO_TEMP_SENSE_ADC,NO_BEMF_RECORDING,NO_SPEED_SENDING,SPEED_RAMP
  c include: ..\..\Inc;..\..\..\..\..\..\..\Middlewares\ST\MC_6Step_Lib\Inc;..\..\..\..\..\..\..\Middlewares\ST\UART_serial_com\Inc;..\..\..\..\..\..\..\Drivers\BSP\STEVAL-SPIN3202;..\..\..\..\..\..\..\Drivers\BSP\Components\stspin32f0;..\..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F0xx\Include;..\..\..\..\..\..\..\Drivers\STM32F0xx_HAL_Driver\Inc
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Drivers/BSP/Components
    ../../../../../../../Drivers/BSP/Components/stspin32f0/: stspin32f0.c
  group Drivers/BSP/STEVAL-SPIN3202
    ../../../../../../../Drivers/BSP/STEVAL-SPIN3202/: STEVAL-SPIN3202.c
  group Drivers/STM32F0xx_HAL_Driver
    ../../../../../../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_usart.c stm32f0xx_hal_spi.c
  group Middlewares/MC_6Step_Lib
    ../../../../../../../Middlewares/ST/MC_6Step_Lib/Src/: 6Step_Lib.c
  group User
    ../../Src/: main_32F0.c stspin32f0_hal_msp.c stspin32f0_it.c SPI_UI.c
    ../../Inc/: MC_SixStep_param_32F0.h MC_SixStep_param_2036_U_024_B_K312.h MC_SixStep_param_BR2804_1700_KV_1.h MC_SixStep_param_FAN_4PP_24V.h MC_SixStep_param_RS_57BL54.h
  group Drivers/BSP/ROV
    ../../../../../../../Drivers/BSP/ROV/: ROV_R1.c
target ROV (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F031C6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: as above
  output: Project_Uart
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=$l@L.bin !L
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ROV,USE_HAL_DRIVER,STM32F031x6,NO_PID,HALL_SENSORS,NO_ALL_WINDINGS_ENERGIZATION,FIXED_HALL_DELAY,NO_PWM_ON_BEMF_SENSING,NO_MC_FAN_4PP_24V,NO_MC_RS_57BL54,NO_MC_2036_U_024_B_K312,NO_MC_BR2804_1700_KV_1,MC_SUPPO_2217_9_950_KV,DELTA_6STEP_TABLE,COMPLEMENTARY_DRIVE,TORQUE_LIMIT_MODE,NO_VOLTAGE_MODE,NO_CURRENT_SENSE_ADC,NO_TEMP_SENSE_ADC,SPEED_RAMP
  c include: ..\..\Inc;..\..\..\..\..\..\..\Middlewares\ST\MC_6Step_Lib\Inc;..\..\..\..\..\..\..\Middlewares\ST\UART_serial_com\Inc;..\..\..\..\..\..\..\Drivers\BSP\ROV;..\..\..\..\..\..\..\Drivers\BSP\Components\stspin32f0;..\..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F0xx\Include;..\..\..\..\..\..\..\Drivers\STM32F0xx_HAL_Driver\Inc
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
software components: CMSIS:CORE 5.0.0, Device:Startup 2.2.3
